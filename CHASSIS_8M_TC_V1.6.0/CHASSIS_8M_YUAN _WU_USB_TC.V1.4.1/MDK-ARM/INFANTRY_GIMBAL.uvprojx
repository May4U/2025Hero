# Keil uVision project INFANTRY_GIMBAL.uvprojx, settings and files
target INFANTRY_GIMBAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: INFANTRY_GIMBAL +hex
  AfterMake: fromelf.exe   --elf -o  ..\..\test.elf  Objects\INFANTRY_GIMBAL.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT=1U,math4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../ACE-ECF;../ACE-ECF/Algorithm/inc;../ACE-ECF/Application/inc;../ACE-ECF/Application/inc/IMU_Driver;../ACE-ECF/Bsp/Inc;../ACE-ECF/Control/Inc;../Task/Inc;../Middlewares/ST/ARM/DSP/Inc;../Application/Inc;../FSM
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Control
    ../ACE-ECF/Control/Src/: robot_cmd.c DJI_Motor.c Cybergear_Motor.c
  group Task
    ../Task/Src/: fire_task.c safe_task.c Init_task.c chassis_task.c referee_task.c
    ../ACE-ECF/Application/src/: imu_task.c
  group Bsp
    ../ACE-ECF/Bsp/Src/: bsp_dr16.c bsp_Motor_Encoder.c bsp_referee.c bsp_can.c pm01_api.c
    ../ACE-ECF/Application/src/: rm_cilent_ui.c
  group Algorithm
    ../ACE-ECF/Algorithm/src/: filter.c fifo.c maths.c pid.c CRC.c lqr.c
  group IMU_Driver
    ../ACE-ECF/Application/src/IMU_Driver/: BMI088driver.c BMI088Middleware.c bsp_dwt.c bsp_PWM.c kalman_filter.c QuaternionEKF.c user_lib.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
software components: CMSIS:CORE 4.3.0
